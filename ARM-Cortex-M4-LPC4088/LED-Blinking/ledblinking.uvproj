# Keil uVision project ledblinking.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: ledblinking +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_LPC407x_8x_177x_8x.s led.c
    C:/Keil/ARM/Startup/NXP/LPC407x_8x_177x_8x/: system_LPC407x_8x_177x_8x.c
